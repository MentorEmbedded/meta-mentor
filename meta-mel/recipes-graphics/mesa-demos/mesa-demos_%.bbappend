bindir_mel = "/opt/${PN}"
EXTRA_OECONF_append_mel = " --bindir=${bindir}"

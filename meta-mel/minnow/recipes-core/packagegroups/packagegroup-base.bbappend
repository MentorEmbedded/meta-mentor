RDEPENDS_packagegroup-base-alsa_append = " alsa-utils-aplay"

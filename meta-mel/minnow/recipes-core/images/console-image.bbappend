#Add aplay package for Audio IN/OUT testing on minnow board
IMAGE_INSTALL_append = " alsa-utils-aplay"


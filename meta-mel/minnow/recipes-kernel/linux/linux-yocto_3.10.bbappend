FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI_append_minnow = " file://0001-kgdboc-change-the-linking-order-of-kgdboc.patch \
"

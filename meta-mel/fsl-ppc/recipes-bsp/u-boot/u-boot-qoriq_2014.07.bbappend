UBOOT_LOCALVERSION = "+${DISTRO_NAME}-${@d.getVar('SDK_VERSION', True).partition('+')[0]}"

IMAGE_INSTALL += " kernel-modules"

IMAGE_INSTALL += " kernel-modules \
                   dosfstools"

inherit image-wic

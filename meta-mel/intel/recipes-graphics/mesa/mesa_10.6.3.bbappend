# Adding GLES3 headers to libgles2-mesa-dev package
FILES_libgles2-mesa-dev += "${includedir}/GLES3"

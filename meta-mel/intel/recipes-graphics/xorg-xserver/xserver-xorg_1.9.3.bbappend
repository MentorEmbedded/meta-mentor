python () { 
    raise bb.parse.SkipPackage("We do not support EMGD for licensing reasons") 
}

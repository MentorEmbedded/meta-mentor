SRCREV:mel = "ac45ee08baceed7c46a75b0776d898f0383f6430"
SRC_URI:mel = "git://github.com/MentorEmbedded/libwebsockets.git;protocol=https;branch=v4.2-stable"

SRCREV:mel = "69b9a77a59dce8212a55f69c3b22cd6fd02dcbbc"
SRC_URI:mel = "git://github.com/MentorEmbedded/libwebsockets.git;protocol=https;branch=v4.1-stable"

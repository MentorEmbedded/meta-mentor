EXTRA_OECONF:append:class-native:mel = " --disable-schedutils"

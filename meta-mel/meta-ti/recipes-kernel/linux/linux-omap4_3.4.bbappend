FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}/${MACHINE}:"

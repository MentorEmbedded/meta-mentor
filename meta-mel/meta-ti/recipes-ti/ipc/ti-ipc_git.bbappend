# specify platform and daemon for DRA7xx using MEL machine name as an override 
PLATFORM_mel-dra7xx-evm = "DRA7XX"
DAEMON_mel-dra7xx-evm = "lad_dra7xx"

B = "${WORKDIR}/git"

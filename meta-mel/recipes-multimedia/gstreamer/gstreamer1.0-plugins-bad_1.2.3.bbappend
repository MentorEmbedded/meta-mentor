PACKAGECONFIG[bluez] = "--enable-bluez,--disable-bluez,virtual/libbluetooth"

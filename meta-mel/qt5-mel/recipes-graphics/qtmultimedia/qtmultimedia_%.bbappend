OE_QMAKE_PATH_EXAMPLES_mel = "/opt/qt5/examples"

SRCREV = "ded76f374e74eb791486183ea4062a565aadb006"
SRC_URI = "git://github.com/MentorEmbedded/libwebsockets.git;protocol=https;branch=v4.0-stable"

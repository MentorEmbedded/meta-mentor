PACKAGECONFIG[bluetooth] = "--enable-bluetooth,--disable-bluetooth,virtual/libbluetooth"

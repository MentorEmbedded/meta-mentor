PROVIDES_append_mel = " virtual/libbluetooth"

PROVIDES += "virtual/libbluetooth"

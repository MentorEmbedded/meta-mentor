SRC_URI_mel = "git://github.com/MentorEmbedded/libdb;branch=5.3"
SRCREV_mel = "81e5dd637b0bd954904130a2a493d3ac281148dc"
PV_mel = "5.3.28+git${SRCPV}"
S_mel = "${WORKDIR}/git"

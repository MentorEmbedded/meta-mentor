DEPENDS_class-nativesdk_append_mel = " nativesdk-openssl"
CURLGNUTLS_class-nativesdk_append_mel = " --without-gnutls --with-ssl"

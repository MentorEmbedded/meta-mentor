DEPENDS_append_class-nativesdk_mel = " nativesdk-openssl"
CURLGNUTLS_class-nativesdk_mel = " --without-gnutls --with-ssl"

EXTRA_OECONF_append_mel = " --datadir=/opt"
FILES_${PN}-examples_append = " /opt/${PN}/*"

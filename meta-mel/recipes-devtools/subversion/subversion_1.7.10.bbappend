APACHE_MIRROR = "http://archive.apache.org/dist"

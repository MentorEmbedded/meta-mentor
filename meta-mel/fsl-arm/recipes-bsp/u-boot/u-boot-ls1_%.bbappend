UBOOT_CONFIG = "sdcard"
RPROVIDES_${PN} = "u-boot"

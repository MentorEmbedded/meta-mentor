# Set default provider of PA conf
RPROVIDES_${PN} += "alsa-plugins-pulseaudio-conf"

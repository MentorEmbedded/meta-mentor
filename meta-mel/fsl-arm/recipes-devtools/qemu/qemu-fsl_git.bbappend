# FIXME: Avoid WARNING due missing patch for native/nativesdk
BBCLASSEXTEND = ""

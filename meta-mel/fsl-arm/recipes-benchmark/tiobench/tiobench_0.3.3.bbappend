
# Force GNU inline semantics, fixes build with GCC5
EXTRA_OEMAKE += 'CFLAGS+="-fgnu89-inline"'

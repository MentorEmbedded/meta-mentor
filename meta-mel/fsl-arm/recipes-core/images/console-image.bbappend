IMAGE_INSTALL += "packagegroup-tools-audio"

FILESEXTRAPATHS_prepend_cyclone5 := "${THISDIR}/files:"

SRC_URI_append_cyclone5 = " file://0001-xserver-common-use-xvfb-as-xserver-if-available.patch"

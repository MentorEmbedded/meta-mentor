FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"
SRC_URI += "file://qbenchmark-disable-perf-if-no-syscall.patch"

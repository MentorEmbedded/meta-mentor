# Silence the already-stripped sysroot warning, we don't care for this
INSANE_SKIP_${PN} += "already-stripped"

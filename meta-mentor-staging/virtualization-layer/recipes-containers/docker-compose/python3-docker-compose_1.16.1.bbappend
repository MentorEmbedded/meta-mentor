
RDEPENDS_${PN} += " python3-misc \
                    python3-modules \
                  "

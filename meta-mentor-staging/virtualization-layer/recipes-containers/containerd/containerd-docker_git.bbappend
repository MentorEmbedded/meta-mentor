
# Specify the proper Host ARCH Flags for building
BUILDSDK_CFLAGS  += "${HOST_CC_ARCH}"
BUILDSDK_LDFLAGS += "${HOST_CC_ARCH}"

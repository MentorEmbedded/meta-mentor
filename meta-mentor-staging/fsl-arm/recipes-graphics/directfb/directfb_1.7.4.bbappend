FILESPATH .= ":${COREBASE}/meta/recipes-graphics/directfb/directfb"

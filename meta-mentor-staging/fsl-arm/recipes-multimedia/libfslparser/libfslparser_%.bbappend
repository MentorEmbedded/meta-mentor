INHIBIT_SYSROOT_STRIP = "1"

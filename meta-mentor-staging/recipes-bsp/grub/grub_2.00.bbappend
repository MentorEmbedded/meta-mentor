FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI_append = " file://0001-Fix-CVE-2015-8370-Grub2-user-pass-vulnerability.patch"

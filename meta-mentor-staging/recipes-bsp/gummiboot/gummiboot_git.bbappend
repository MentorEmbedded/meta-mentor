FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://configure-allow-setting-EFI_CC.patch"


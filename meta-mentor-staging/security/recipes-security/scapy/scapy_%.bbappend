RDEPENDS_${PN} += "python-compression python-core python-crypt python-ctypes \
        python-datetime python-fcntl python-io python-lang python-logging \
        python-math python-netclient python-numbers python-pickle python-pycrypto \
        python-shell python-subprocess python-threading python-zlib"

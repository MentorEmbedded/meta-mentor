FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"
SRC_URI += "file://check-setuid-use-more-portable-find-args.patch"

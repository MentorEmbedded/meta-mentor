EXTRA_OECONF_append_linux-gnux32 = " --disable-asm"

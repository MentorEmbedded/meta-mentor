SRC_URI += "${SOURCEFORGE_MIRROR}/libpng/libpng16/patch-libpng-1.6.0-1.6.9-vu684412.diff;name=cve20140333.patch;striplevel=0"
SRC_URI[cve20140333.patch.md5sum] = "79bfa6f7f90c272992ea11da6af4b943"
SRC_URI[cve20140333.patch.sha256sum] = "d656ff0a5e14ad2b0bcd7b18c97380d9438bd1d8324532b0bee7826bf06402b5"

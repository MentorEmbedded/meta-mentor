FILESEXTRAPATHS_prepend := "${THISDIR}:"
SRC_URI += "file://libtiff-CVE-2013-1961.patch"

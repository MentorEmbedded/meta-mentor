PACKAGECONFIG[x11] = "--with-x,--without-x,virtual/libx11 libxext libxv libice libsm"

# mount /etc/systemd with rw rights.
VOLATILE_BINDS += "\
/var/volatile/systemd /etc/systemd\n\
"

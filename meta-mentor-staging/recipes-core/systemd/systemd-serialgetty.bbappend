FILESEXTRAPATHS_prepend := "${THISDIR}/systemd-serialgetty:"


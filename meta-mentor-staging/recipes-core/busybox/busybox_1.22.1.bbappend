FILESEXTRAPATHS_prepend := "${THISDIR}/busybox:"
SRC_URI += "file://0001-build-system-Specify-nostldlib-when-linking-to-.o-fi.patch"

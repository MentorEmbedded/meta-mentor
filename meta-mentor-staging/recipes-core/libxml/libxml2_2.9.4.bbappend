FILESEXTRAPATHS_prepend := "${THISDIR}/libxml2:"
SRC_URI += "file://CVE-2016-5131.patch"

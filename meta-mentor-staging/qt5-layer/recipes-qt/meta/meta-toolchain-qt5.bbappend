FEATURE_PACKAGES_qtcreator-debug := "${PACKAGE_GROUP_qtcreator-debug}"
PACKAGE_GROUP_qtcreator-debug = ""

LICENSE = "TI-TSPA-with-Thai-OSSC & BSD-3-Clause & BSL-1.0 & Hewlett-Packard & AFL-3.0 & MIT & BSD-2-Clause & PD & Other"

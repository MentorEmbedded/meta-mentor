FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://parallel-firmware-install.patch"

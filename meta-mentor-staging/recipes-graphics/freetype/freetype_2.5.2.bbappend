FILESEXTRAPATHS_prepend := "${THISDIR}:"
SRC_URI += "file://freetype-CVE-2014-2240.patch \
	   file://freetype-CVE-2014-2241.patch"

# ---------------------------------------------------------------------------------------------------------------------
# SPDX-License-Identifier: MIT
# ---------------------------------------------------------------------------------------------------------------------

CFLAGS_append_class-native = " -DNO_SHARED_MEMORY"

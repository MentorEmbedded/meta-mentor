FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-Fix-subwindow-in-Xi-emulated-events.patch"


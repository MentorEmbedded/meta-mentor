FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://CVE-2016-7951-CVE-2016-7952-libxtst.patch \
	   "

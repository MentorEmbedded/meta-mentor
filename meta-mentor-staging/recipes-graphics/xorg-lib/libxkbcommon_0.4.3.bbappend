PACKAGECONFIG[x11] += "xkeyboard-config"

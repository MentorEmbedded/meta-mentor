FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://CVE-2016-7944-libXfixes.patch \
	   "

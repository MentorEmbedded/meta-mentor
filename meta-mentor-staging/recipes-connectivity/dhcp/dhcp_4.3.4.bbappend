FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://0001-dhcp-correct-the-intention-for-xml2-lib-search.patch"

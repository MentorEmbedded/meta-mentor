DEPENDS += "avahi libaio"

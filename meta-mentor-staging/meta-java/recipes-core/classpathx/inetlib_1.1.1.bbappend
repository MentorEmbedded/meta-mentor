oe_jarinstall_prepend() {
    rm -rf ${D}${datadir_java}/${ALTJARFILENAMES}
}

FILESEXTRAPATHS_prepend := "${THISDIR}:"
SRC_URI += "file://ecpg-parallel-make-fix.patch"

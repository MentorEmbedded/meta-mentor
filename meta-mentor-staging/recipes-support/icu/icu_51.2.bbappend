FILESEXTRAPATHS_prepend := "${THISDIR}:"
SRC_URI += "file://icu-CVE-2013-2924.patch"

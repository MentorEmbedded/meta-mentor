FILESEXTRAPATHS_prepend := "${THISDIR}:"
SRC_URI += "file://libssh-CVE-2014-0017.patch"

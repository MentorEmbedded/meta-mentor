FILESEXTRAPATHS_prepend := "${THISDIR}:"
SRC_URI += "file://gnutls-CVE-2013-2116.patch"

PACKAGES =+ "${PN}-xssl"
FILES_${PN}-xssl = "${libdir}/libgnutls-xssl.so.*"
LICENSE_${PN}-xssl = "LGPLv2.1+"

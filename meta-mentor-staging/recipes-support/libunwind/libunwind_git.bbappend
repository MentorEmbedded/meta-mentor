FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://libunwind-1.1-x32.patch"


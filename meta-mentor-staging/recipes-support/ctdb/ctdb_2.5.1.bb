RDEPENDS_${PN} += "bash"

RDEPENDS_${PN} += "bash"

SYSTEMD_AUTO_ENABLE = "disable"

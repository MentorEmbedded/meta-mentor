PACKAGECONFIG[gssapi] = "--with-gssapi,--without-gssapi,krb5"

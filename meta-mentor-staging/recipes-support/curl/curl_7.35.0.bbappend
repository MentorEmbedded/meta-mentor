FILESEXTRAPATHS_prepend := "${THISDIR}:"
SRC_URI += "file://libcurl-cve-2014-0138.patch"

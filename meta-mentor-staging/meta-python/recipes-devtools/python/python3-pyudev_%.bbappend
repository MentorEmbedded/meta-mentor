RDEPENDS_${PN}_append_feature-mentor-staging = "\
    ${PYTHON_PN}-fcntl \
"

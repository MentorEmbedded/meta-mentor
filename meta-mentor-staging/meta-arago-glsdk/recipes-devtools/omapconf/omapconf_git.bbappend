LICENSE = "GPLv2 & BSD"

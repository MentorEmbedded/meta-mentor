CFLAGS += " -mno-outline-atomics"

DEPENDS_remove = "libav"
DEPENDS += "ffmpeg"

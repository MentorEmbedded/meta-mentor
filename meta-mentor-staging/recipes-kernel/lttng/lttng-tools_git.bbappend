FILESEXTRAPATHS_prepend := "${THISDIR}/lttng-tools:"
SRC_URI_append_linux-gnux32 = " file://x32.patch"

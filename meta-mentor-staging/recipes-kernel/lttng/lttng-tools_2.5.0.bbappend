FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"

SRC_URI += "file://UST_subbuffers_silently_dropped_on_moderate_trace_traffic.patch \
	  "



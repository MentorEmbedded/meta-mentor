# update to latest stable revision
SRCREV = "08e7bdfb4957084a0cbf139867f009dc770ed4c4"
PV = "2.4.1"

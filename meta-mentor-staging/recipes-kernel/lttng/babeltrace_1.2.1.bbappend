DEPENDS += "bison-native flex-native"

FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://powerpc_align_TOC_to_256_bytes.patch"

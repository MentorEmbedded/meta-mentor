FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"
SRC_URI += "file://fix-undefined-O_CLOEXEC.patch"

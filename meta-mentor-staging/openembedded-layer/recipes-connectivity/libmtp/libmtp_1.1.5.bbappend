inherit gettext

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Ensure-we-check-for-stdbool.h.patch"


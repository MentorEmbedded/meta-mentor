FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://0001-demux_ogg-partially-port-libtheora-glue-code-to-Theo.patch"

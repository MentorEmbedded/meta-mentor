DEPENDS += "makedepend-native"

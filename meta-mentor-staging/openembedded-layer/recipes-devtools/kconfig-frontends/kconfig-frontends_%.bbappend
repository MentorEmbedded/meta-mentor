DEPENDS += "flex-native"
DEPENDS_remove = "flex bison"

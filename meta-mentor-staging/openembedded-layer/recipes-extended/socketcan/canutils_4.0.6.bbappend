#add iproute2 to configure CAN interface
RDEPENDS_${PN} += "iproute2"

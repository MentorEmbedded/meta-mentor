DEPENDS += "konkretcmpi-native"

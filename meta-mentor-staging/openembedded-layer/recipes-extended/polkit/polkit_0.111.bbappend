FILESEXTRAPATHS_prepend := "${THISDIR}/polkit:"
SRC_URI += "file://polkit-CVE-2013-4288.patch"


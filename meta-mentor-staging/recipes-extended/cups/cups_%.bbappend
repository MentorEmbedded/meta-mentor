EXTRA_OECONF += "DSOFLAGS='${LDFLAGS}'"

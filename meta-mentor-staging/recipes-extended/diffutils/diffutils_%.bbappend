CFLAGS += "-Wno-error"
CACHED_CONFIGUREVARS += "gl_cv_func_getopt_gnu=yes"

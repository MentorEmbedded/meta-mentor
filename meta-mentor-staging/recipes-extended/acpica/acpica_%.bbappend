DEPENDS += "flex-native bison-native"

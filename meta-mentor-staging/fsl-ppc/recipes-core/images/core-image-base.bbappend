# Added vfat support for powerpc boards
IMAGE_INSTALL_append_mel = " dosfstools"

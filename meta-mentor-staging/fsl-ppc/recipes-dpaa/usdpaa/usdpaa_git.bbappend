FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-usdpaa-do-not-hardcode-flags-for-powerpc64.patch"

TARGET_CC_ARCH += "${LDFLAGS}"

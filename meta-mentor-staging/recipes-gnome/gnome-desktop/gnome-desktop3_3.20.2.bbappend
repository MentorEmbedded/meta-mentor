FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://gnome-desktop-thumbnail-don-t-convert-time_t-to-long.patch"


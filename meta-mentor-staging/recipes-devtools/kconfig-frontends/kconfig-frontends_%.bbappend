DEPENDS += "flex-native bison-native"
DEPENDS_remove = "flex bison"

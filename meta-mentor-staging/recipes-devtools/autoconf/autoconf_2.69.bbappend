RDEPENDS_${PN} += "perl-module-data-dumper"

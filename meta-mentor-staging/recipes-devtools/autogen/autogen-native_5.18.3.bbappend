inherit pkgconfig

# Gold fails to build for x32
LDGOLD_linux-gnux32 = ""
USE_ALTERNATIVES_FOR_remove_linux-gnux32 = "ld.gold"

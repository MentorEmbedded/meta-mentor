FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-tcf-client-Add-LDFLAGS-to-fix-QA-Warning.patch"

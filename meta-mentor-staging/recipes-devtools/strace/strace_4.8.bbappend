FILESEXTRAPATHS_prepend := "${THISDIR}:"
SRC_URI += "file://0001-Work-around-conflict-between-sys-ptrace.h-and-linux-.patch"

do_compile_prepend () {
    rm -rf .ext/rdoc
}

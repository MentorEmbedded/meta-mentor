FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "\
    file://0001-site.py-obey-sys.lib-for-sitepackages.patch \
"

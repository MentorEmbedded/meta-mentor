DEPENDS += "python3-vcversioner-native"
DEPENDS_remove = "python3-vcversioner"

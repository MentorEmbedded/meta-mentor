FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://0001-python-native-fix-one-do_populate_sysroot-warning.patch"

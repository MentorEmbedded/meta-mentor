FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://use-libsystemd.patch"

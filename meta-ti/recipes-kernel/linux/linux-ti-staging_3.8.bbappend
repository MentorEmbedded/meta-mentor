FILESEXTRAPATHS_prepend :="${THISDIR}:"

SRC_URI +="file://files/fix_kernel_load_1.patch \
 	   file://files/fix_kernel_load_2.patch"

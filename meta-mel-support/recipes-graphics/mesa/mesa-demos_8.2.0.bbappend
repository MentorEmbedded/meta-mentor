PACKAGECONFIG_remove_mel = " glx"

require recipes-core/images/core-image-minimal-initramfs.bb
export IMAGE_BASENAME = "${PN}"

PRINC := "${@int(PRINC) + 1}"
EXTRA_OECONF += "--disable-xen"

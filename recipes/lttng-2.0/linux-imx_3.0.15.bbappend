PR = "${PR}.a"

SRC_URI_append := "file://${THISDIR}/linux/commit-4ff16c2.patch"


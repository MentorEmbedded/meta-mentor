MACHINE_KERNEL_PR_append = "b"

SRC_URI_append := "file://${THISDIR}/linux-omap4/commit-4ff16c2.patch"

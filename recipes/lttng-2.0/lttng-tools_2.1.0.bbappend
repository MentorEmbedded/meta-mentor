PRINC := "${@int(PRINC) + 1}"

SRCREV = "3604f373dd93990e0fd6342cfe4c657efaa171bb"
PV .= "+git${SRCPV}"

EXTRA_OECONF +=  "CC_BUILD='${BUILD_CC}'"

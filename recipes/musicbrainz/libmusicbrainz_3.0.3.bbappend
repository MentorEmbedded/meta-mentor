PRINC := "${@int(PRINC) + 1}"

LDFLAGS += "-lpthread"

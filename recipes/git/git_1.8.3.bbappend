create_wrapper () {
    :
}

EXTRA_OEMAKE += "'RUNTIME_PREFIX=1'"

# Make the build deterministic with regard to valgrind support
EXTRA_OECONF += "--disable-valgrind"

# This recipe is actually GPLv2+, not GPLv3, see
# http://git.gnome.org/browse/gnome-common/commit/?id=ce863d9 for the details.
# Also, the current version of this recipe in oe-core has this LICENSE.
LICENSE = "GPLv2+"
PR .= ".1"

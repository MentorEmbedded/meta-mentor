PRINC := "${@int(PRINC) + 1}"
inherit gettext

PR .= ".1"
EXTRA_OECONF += "\
	ac_cv_path_PYTHON=/not/exist \
"

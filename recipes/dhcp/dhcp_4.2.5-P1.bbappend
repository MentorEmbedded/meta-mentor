FILESEXTRAPATHS_prepend := "${THISDIR}/dhcp:"
SRC_URI += "file://replace-ifconfig-route.patch \
           "

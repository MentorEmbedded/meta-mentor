require recipes-support/nano/nano_${PV}.bb

BPN = "nano"
EXTRA_OECONF = "--enable-tiny"

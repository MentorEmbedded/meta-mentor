PRINC := "${@int(PRINC) + 1}"
RREPLACES_${PN} += "nano-tiny"

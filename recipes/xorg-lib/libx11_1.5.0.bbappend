EXTRA_OECONF += "--disable-selective-werror"
EXTRA_OEMAKE += "'CWARNFLAGS='"

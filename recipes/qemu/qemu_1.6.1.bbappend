FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"
SRC_URI += "file://linux-user-Handle-SOCK_CLOEXEC-NONBLOCK-if-unavailab.patch"

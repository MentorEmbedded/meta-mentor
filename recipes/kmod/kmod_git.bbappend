do_install_ptest_base () {
    :
}

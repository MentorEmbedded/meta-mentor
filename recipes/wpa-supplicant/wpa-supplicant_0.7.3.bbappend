PR .= ".1"
FILESEXTRAPATHS_prepend := "${THISDIR}:"
SRC_URI += "file://dso-link-change.patch"

PR = "r5"

DEPENDS += "gettext-native"


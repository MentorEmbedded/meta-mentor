LICENSE_${PN}-sd8686 = "Firmware-LICENSE.libertas"
LICENSE_${PN}-rtl8192cu = "Firmware-LICENSE.rtlwifi_firmware"
LICENSE_${PN}-rtl8192ce = "Firmware-LICENSE.rtlwifi_firmware"
LICENSE_${PN}-rtl8192su = "Firmware-LICENSE.rtlwifi_firmware"

PACKAGES_DYNAMIC += "^libpcre.*"

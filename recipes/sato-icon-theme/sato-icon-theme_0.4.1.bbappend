PRINC := "${@int(PRINC) + 1}"
inherit perlnative

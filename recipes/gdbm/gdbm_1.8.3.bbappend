PR .= ".1"
FILESEXTRAPATHS_prepend := "${THISDIR}/gdbm:"
SRC_URI += "file://ldflags.patch"

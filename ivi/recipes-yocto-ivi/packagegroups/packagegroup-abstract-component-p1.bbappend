RDEPENDS_${PN}_remove = "bluez4 bluez4-systemd"
RDEPENDS_${PN} += "packagegroup-base-bluetooth"

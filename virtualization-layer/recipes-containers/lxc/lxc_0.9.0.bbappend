FILESEXTRAPATHS_prepend := "${THISDIR}/lxc:"
SRC_URI += "file://lxc-busybox-fixes.patch"
